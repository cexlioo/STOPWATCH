# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=3 wLevel=2
  c include: .\Drivers;.\System;.\FreeRTOS\inc;.\FreeRTOS\portable;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Drivers
    ./Drivers/: key.c key.h led.c led.h usart.c usart.h linked_queue.c linked_queue.h at_interface.c at_interface.h at_M100p.c at_M100p.h ringbuffer.c ringbuffer.h AHT10.c AHT10.h GPS.c GPS.h i2c.h i2c_hard.c i2c_soft.c OLED.c OLED.h OLED_Font.h spi.h spi_hard.c spi_soft.c w25qxx.c w25qxx.h W25QxxInstruction.h
  group System
    ./System/: system.c system.h log.c log.h
  group User
    ./User/: main.c stm32f10x_it.c bike.c bike.h cJSON.c cJSON.h flash_data.c flash_data.h flash_index.c flash_index.h screen.c screen.h utils.c utils.h
  group FreeRTOS
    ./FreeRTOS/portable/: heap_4.c port.c
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/inc/: FreeRTOSConfig.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
